# Repository whatnick/Grove_Pulse_Counter

## EAGLE design Grove_Pulse_Counter.brd

Parts:
C1, C2: 1uF; C0603
C3: 100nF; C0603
D1: DS1683S+; SOIC8-N_MC
H1: RED; CHIPLED_0603
J1: 2p-smd-1.0-90d; HW2-SMD-1.0-90D
J2: H4P-SMD-2.0; HW4-SMD-2.0
R1: 511R; R0603
R2: 10K; R0603
R7: 10K; 1206-8-3.3X2.4
U2: BSS138PS; SOT65P210X110-6N
U3: XC6206MR; SOT23

Connections:
3.3V: C2.2, C3.2, D1.8 (VCC), R1.2, R2.1, R7.5 (2), R7.6 (2), U2.2 (G1), U2.5 (G2), U3.2 (VOUT)
5V: C1.2, J2.3, R7.1, R7.2 (1), U3.3 (VIN)
ALARM: D1.3 (ALARM), H1.C
EVENT: D1.1 (EVENT), J1.+ (1), R2.2
GND: C1.1, C2.1, C3.1, D1.4 (GND), J1.3, J1.4, J1.- (2), J2.4, J2.SS1, J2.SS2, U3.1 (VSS)
unnamed: H1.A, R1.1
SCL: J2.1, R7.7 (2), U2.3 (D2)
SDA: J2.2, R7.8 (2), U2.6 (D1)
T_SCL: D1.5 (SCL), R7.4 (1), U2.4 (S2)
T_SDA: D1.6 (SDA), R7.3 (1), U2.1 (S1)

Notes on the sheet:
稳压电路

Board: 2 copper layers, 20.0 x 24.2 mm, 15 parts (3 on the bottom side), 10 nets.

Other parts of the board:
U$2: 1U-DIM-W/-DRILL
U$3: TWIGLOGO
U$4: OSHW_FILLX200_NOTEXT

## Commit log

2016-08-29 Initial import
